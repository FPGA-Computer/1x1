# Keil uVision project STM32F030F4 IoT proj.uvproj, settings and files
target Blinky (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: blinky
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: startup_stm32f030.s blinky-main.c stm32f030 iot.h
  group Listing
    ./Listings/: blinky.map startup_stm32f030.lst
